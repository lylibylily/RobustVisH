options:
  parameters:
    author: Z
    generate_options: no_gui
    id: gmsk_visual
    output_language: python
    title: gmsk for visual data
  states: {}

blocks:
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.046'
    noise_type: analog.GR_IMPULSE
    seed: '42'
    type: float
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: '0.054'
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Z\Desktop\v1-1.jpg
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Z\Desktop\v1.jpg
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_float_to_complex_0, '0']
- [analog_noise_source_x_1, '0', blocks_add_xx_0, '2']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0, '0', digital_gmsk_mod_0, '0']
- [blocks_float_to_complex_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', digital_gmsk_demod_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [digital_gmsk_demod_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_gmsk_mod_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
